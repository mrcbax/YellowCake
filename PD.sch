File: PD.sch (KiCad schematic (older format))
At the start: 90 parts, among them U2 ISL95837HRZ-T

Commit message: finishing schematic
Parts:
- gave numbers to parts that had none: 36
